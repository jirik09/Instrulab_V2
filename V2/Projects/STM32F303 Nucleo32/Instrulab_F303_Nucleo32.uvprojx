# Keil uVision project Instrulab_F303_Nucleo32.uvprojx, settings and files
target Instrulab - F303 Nucleo32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00003000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Instrulab_F303_Nucleo32 +hex
  AfterMake: fromelf --bin --output ..\..\Bin\Instrulab_F303_Nucleo32.bin Instrulab_built\Instrulab_F303_Nucleo32.axf
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xx,ARM_MATH_CM4,USE_SCOPE,USE_GEN
  c misc: --C99
  c include: Inc;..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Common;..\..\Drivers\BSP\STM32F3xx_Nucleo_32
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --diag_suppress=L6329
  group Application/User
    Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c main.c tim.c dma.c dac.c adc.c gpio.c freertos.c usart.c comms_hal.c
    ./Src/: clock.c
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303x8.s
  group Drivers/BSP
    ../../Drivers/BSP/STM32F3xx_Nucleo_32/: stm32f3xx_nucleo_32.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c queue.c croutine.c list.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Common
    ../../Common/: cmd_parser.c comms.c scope.c generator.c counter.c sync_pwm.c logic_analyzer.c
software components: CMSIS:CORE 4.2.0
