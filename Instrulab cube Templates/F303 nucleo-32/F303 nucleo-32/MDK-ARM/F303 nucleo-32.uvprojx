# Keil uVision project F303 nucleo-32.uvprojx, settings and files
target F303 nucleo-32 Configuration (ARM-ADS)
  device: STM32F303K8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: F303 nucleo-32 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303x8
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32F3xx_HAL_Driver/Inc;     ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;     ../Middlewares/Third_Party/FreeRTOS/Source/include;     ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;     ../Drivers/CMSIS/Include;     ../Drivers/CMSIS/Device/ST/STM32F3xx/Include
  asm include: ..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c croutine.c list.c tasks.c timers.c queue.c croutine.c list.c tasks.c timers.c queue.c croutine.c list.c tasks.c timers.c queue.c croutine.c list.c tasks.c timers.c queue.c croutine.c list.c tasks.c timers.c queue.c croutine.c list.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c port.c port.c port.c port.c port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c cmsis_os.c cmsis_os.c cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c heap_4.c heap_4.c heap_4.c heap_4.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303x8.s startup_stm32f303x8.s startup_stm32f303x8.s startup_stm32f303x8.s startup_stm32f303x8.s startup_stm32f303x8.s
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c freertos.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c freertos.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c freertos.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c freertos.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c freertos.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c freertos.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
